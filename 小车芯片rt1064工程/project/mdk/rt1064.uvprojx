# Keil uVision project rt1064.uvprojx, settings and files
target nor_sdram_zf_dtcm (6210000::V6.21::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.25.06.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1064
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1, FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0, USB_STACK_BM, DEBUG, MCUXPRESSO_SDK, SD_ENABLED
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -Wno-invalid-source-encoding
  c include: ..\user\inc;..\code;..\..\libraries\sdk\startup\mdk;..\..\libraries\sdk\deceive;..\..\libraries\sdk\drives;..\..\libraries\sdk\xip;..\..\libraries\sdk\utilities;..\..\libraries\sdk\utilities\debug_console;..\..\libraries\sdk\utilities\str;..\..\libraries\sdk\cmsis_drivers;..\..\libraries\sdk\components\lists;..\..\libraries\sdk\components\osa;..\..\libraries\sdk\components\serial_manager;..\..\libraries\sdk\components\uart;..\..\libraries\sdk\board;..\..\libraries\components\fatfs\source;..\..\libraries\components\fatfs\source\fsl_sd_disk;..\..\libraries\components\sdmmc;..\..\libraries\components\sdmmc\common;..\..\libraries\components\sdmmc\host\usdhc;..\..\libraries\components\sdmmc\osa;..\..\libraries\components\sdmmc\sd;..\..\libraries\components\usb\device;..\..\libraries\components\usb\include;..\..\libraries\components\usb\phy;..\..\libraries\components\usb\usb_cdc_adapter;..\..\libraries\zf_common;..\..\libraries\zf_driver;..\..\libraries\zf_device;..\..\libraries\components\eiq\tensorflow-lite\examples\kws;..\..\libraries\components\eiq\tensorflow-lite\examples\common\audio;..\..\libraries\components\eiq\common\audio;..\..\libraries\components\eiq\common\model;..\..\libraries\components\eiq\common;..\..\libraries\components\eiq\tensorflow-lite\third_party\flatbuffers\include;..\..\libraries\components\eiq\tensorflow-lite\third_party\gemmlowp;..\..\libraries\components\eiq\tensorflow-lite\third_party\ruy;..\..\libraries\components\eiq\tensorflow-lite\third_party\cmsis;..\..\libraries\components\eiq\tensorflow-lite\third_party\cmsis\CMSIS\NN\Include;..\..\libraries\components\eiq\tensorflow-lite\third_party\cmsis\CMSIS\Core\Include;..\..\libraries\components\eiq\tensorflow-lite\third_party\cmsis\CMSIS\DSP\Include;..\..\libraries\components\eiq\tensorflow-lite\examples\kws;..\..\libraries\components\eiq\tensorflow-lite;..\..\libraries\components\eiq\tensorflow-lite\examples\common\audio;..\..\libraries\sdk\CMSIS\Driver\Include;..\..\libraries\sdk\CMSIS\Include;..\..\libraries\components\CMSIS\DSP\Include;..\..\libraries\components\CMSIS\DSP\Include\dsp;..\..\libraries\components\CMSIS\DSP\PrivateInclude;..\..\libraries\components\CMSIS\DSP\Source\DistanceFunctions;..\..\libraries\components\CMSIS\Core\Include;..\user\inc;..\user\src;..\mdk
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..\..\libraries\components\eiq\tensorflow-lite\examples\kws
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler
  group user_c
    ../user/src/: isr.c main.c run_kws_model_demo.c user_function.c wit_c_sdk.c
    ./: JY901.c
  group user_h
    ../user/inc/: isr.h run_kws_model_demo.h user_function.h wit_c_sdk.h REG.h
    ./: JY901.h
  group doc
    ../../libraries/doc/: GPL3_permission_statement.txt read me.txt version.txt
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h zf_common_vector.c zf_common_vector.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_csi.c zf_driver_csi.h zf_driver_delay.c zf_driver_delay.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_flexio_csi.c zf_driver_flexio_csi.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_romapi.c zf_driver_romapi.h zf_driver_sdio.c zf_driver_sdio.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_gps_tau1201.c zf_device_gps_tau1201.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_flexio.c zf_device_mt9v03x_flexio.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_scc8660_flexio.c zf_device_scc8660_flexio.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h
  group sdk_drivers
    ../../libraries/sdk/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexram_allocate.c fsl_flexram_allocate.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group sdk_device
    ../../libraries/sdk/board/: board.c board.h clock_config.c clock_config.h
    ../../libraries/sdk/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkmimxrt1064_sdram_ini_dcd.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_flexspi_nor_config.h evkmimxrt1064_flexspi_nor_config.c
    ../../libraries/sdk/deceive/: system_MIMXRT1064.h system_MIMXRT1064.c MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
    ../../libraries/sdk/startup/mdk/: startup_MIMXRT1064.S
    ../../libraries/sdk/utilities/: fsl_assert.c
    ../../libraries/sdk/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../../libraries/sdk/components/lists/: fsl_component_generic_list.c
    ../../libraries/sdk/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
    ../../libraries/sdk/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group components_fatfs
    ../../libraries/components/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    ../../libraries/components/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group components_sdmmc
    ../../libraries/components/sdmmc/: sdmmc_config.c sdmmc_config.h
    ../../libraries/components/sdmmc/common/: fsl_sdmmc_common.c fsl_sdmmc_common.h fsl_sdmmc_spec.h
    ../../libraries/components/sdmmc/host/usdhc/: fsl_sdmmc_host.h
    ../../libraries/components/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../libraries/components/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
    ../../libraries/components/sdmmc/sd/: fsl_sd.c fsl_sd.h
  group components_usb
    ../../libraries/components/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device.h
    ../../libraries/components/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../libraries/components/usb/phy/: usb_phy.c usb_phy.h
    ../../libraries/components/usb/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group components_eiq
    ../../libraries/components/eiq/tensorflow-lite/examples/: model.cpp
    ../../libraries/components/eiq/tensorflow-lite/examples/kws/: audio_data.h demo_config.h labels.h model_data.h model_data.s model_ds_cnn_ops_micro.cpp output_postproc.cpp
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.c common.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.cpp error_reporter.h flatbuffer_conversions.cpp flatbuffer_conversions.h op_resolver.cpp op_resolver.h tensor_utils.cpp tensor_utils.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.cpp quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/optimized/: neon_check.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/: add.h add_n.h arg_min_max.h batch_to_space_nd.h binary_function.h ceil.h comparisons.h concatenation.h conv.h cumsum.h depth_to_space.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h elu.h exp.h fill.h floor.h floor_div.h floor_mod.h fully_connected.h hard_swish.h l2normalization.h leaky_relu.h log_softmax.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h portable_tensor_utils.cpp portable_tensor_utils_impl.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_bilinear.h resize_nearest_neighbor.h round.h slice.h softmax.h space_to_batch_nd.h space_to_depth.h strided_slice.h sub.h tanh.h transpose.h transpose_conv.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h mean.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/: all_ops_resolver.cpp all_ops_resolver.h debug_log.cpp debug_log.h fake_micro_context.cpp fake_micro_context.h flatbuffer_utils.cpp flatbuffer_utils.h memory_helpers.cpp memory_helpers.h micro_allocator.cpp micro_allocator.h micro_arena_constants.h micro_context.cpp micro_context.h micro_error_reporter.cpp micro_error_reporter.h micro_graph.cpp micro_graph.h micro_interpreter.cpp micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cpp micro_profiler.h micro_resource_variable.cpp micro_resource_variable.h micro_string.cpp micro_string.h micro_time.cpp micro_time.h micro_utils.cpp micro_utils.h recording_micro_allocator.cpp recording_micro_allocator.h recording_simple_memory_allocator.cpp recording_simple_memory_allocator.h simple_memory_allocator.cpp simple_memory_allocator.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.cpp activations.h activations_common.cpp add.cpp add_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_to_space_nd.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp circular_buffer.h circular_buffer_common.cpp comparisons.cpp concatenation.cpp conv.cpp conv_common.cpp cumsum.cpp depth_to_space.cpp depthwise_conv.cpp depthwise_conv_common.cpp dequantize.cpp dequantize_common.cpp detection_postprocess.cpp elementwise.cpp elu.cpp ethosu.cpp ethosu.h exp.cpp expand_dims.cpp fill.cpp floor.cpp floor_div.cpp floor_mod.cpp fully_connected.cpp fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish_common.cpp if.cpp kernel_runner.h kernel_util.cpp kernel_util.h l2_pool_2d.cpp l2norm.cpp leaky_relu.cpp leaky_relu_common.cpp log_softmax.cpp logical.cpp logical.h logical_common.cpp logistic.cpp logistic_common.cpp maximum_minimum.cpp micro_ops.h mirror_pad.cpp mul.cpp mul_common.cpp neg.cpp pack.cpp pad.cpp pooling.cpp pooling_common.cpp prelu.cpp prelu_common.cpp quantize.cpp quantize_common.cpp read_variable.cpp reduce.cpp reshape.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp round.cpp shape.cpp slice.cpp softmax.cpp softmax_common.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squeeze.cpp strided_slice.cpp sub.cpp sub_common.cpp svdf.cpp svdf.h svdf_common.cpp tanh.cpp transpose.cpp transpose_conv.cpp unpack.cpp var_handle.cpp zeros_like.cpp
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cpp greedy_memory_planner.h linear_memory_planner.cpp linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.cpp non_persistent_buffer_planner_shim.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.cpp schema_utils.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/: portable_type_to_tflitetype.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/flatbuffers/include/flatbuffers/: allocator.h array.h base.h buffer.h buffer_ref.h default_allocator.h detached_buffer.h flatbuffer_builder.h flatbuffers.h flexbuffers.h stl_emulation.h strings.h struct.h table.h util.h vector.h vector_downward.h verifier.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/gemmlowp/fixedpoint/: fixedpoint.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/gemmlowp/internal/: detect_platform.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/ruy/ruy/profiler/: instrumentation.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_cm55.h core_sc000.h core_sc300.h core_star.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Include/: arm_nn_math_types.h arm_nn_tables.h arm_nn_types.h arm_nnfunctions.h arm_nnsupportfunctions.h
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_fast_s16.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_s8.c arm_convolve_s16.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_s8.c arm_fully_connected_s16.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_pool_q7_HWC.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    ../../libraries/components/eiq/tensorflow-lite/third_party/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c
    ../../libraries/components/eiq/common/model/: get_top_n.cpp get_top_n.h model.h output_postproc.h
    ../../libraries/components/eiq/common/: demo_info.h eiq_common.h eiq_iui.h eiq_iworker.h timer.c timer.h
    ../../libraries/components/eiq/common/audio/: audio.h audio_capture.cpp eiq_audio_worker.c eiq_audio_worker.h eiq_micro.c eiq_micro.h eiq_micro_conf.h eiq_speaker.c eiq_speaker.h eiq_speaker_conf.c eiq_speaker_conf.h
    ../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/: padding.h kernel_utils.cpp op_macros.h
    ../../libraries/components/eiq/tensorflow-lite/examples/common/audio/: kws_mfcc.cpp mfcc.cpp
  group components_CMSIS
    ../../libraries/components/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_math_memory.h arm_math_types.h arm_mve_tables.h arm_vec_math.h
    ../../libraries/components/CMSIS/DSP/Include/dsp/: basic_math_functions.h bayes_functions.h complex_math_functions.h controller_functions.h distance_functions.h fast_math_functions.h filtering_functions.h interpolation_functions.h matrix_functions.h none.h quaternion_math_functions.h statistics_functions.h support_functions.h svm_defines.h svm_functions.h transform_functions.h utils.h
    ../../libraries/components/CMSIS/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
    ../../libraries/components/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../libraries/components/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c
    ../../libraries/components/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
